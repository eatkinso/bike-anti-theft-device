# IAR project FatFs_uSD_Standalone.ewp, settings and files
configuration FatFs_uSD_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M4 ST STM32WL55JC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32WL55xx
  ICCARM.CCIncludePath2: ..\FATFS\App; ..\Core\Inc; ..\FATFS\Target; ..\..\..\..\..\..\Drivers\BSP\STM32WLxx_Nucleo; ..\..\..\..\..\..\Drivers\STM32WLxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32WLxx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WLxx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FatFs_uSD_Standalone.hex
  ILINK.IlinkOutputFile: FatFs_uSD_Standalone.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wlxx_hal_msp.c stm32wlxx_it.c
  group Application/User/FATFS/App
    ../FATFS/App/: app_fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: adafruit_802.c adafruit_802_sd.c sd_diskio.c stm32wlxx_nucleo_bus.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_spi_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_ll_adc.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c
