# IAR project SubGHz_Phy_PingPong_DualCore_CM0PLUS.ewp, settings and files
configuration SubGHz_Phy_PingPong_DualCore_CM0PLUS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M0+ ST STM32WL55JC_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM0PLUS; USE_HAL_DRIVER; STM32WL55xx
  ICCARM.CCIncludePath2: ../CM0PLUS/Core/Inc; ../CM0PLUS/SubGHz_Phy/App; ../CM0PLUS/SubGHz_Phy/Target; ../CM0PLUS/MbMux; ../Common/Board; ../Common/System; ../Common/MbMux; ../../../../../../Drivers/BSP/STM32WLxx_Nucleo; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/timer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SubGHz_Phy_PingPong_DualCore_CM0PLUS.hex
  ILINK.IlinkOutputFile: SubGHz_Phy_PingPong_DualCore_CM0PLUS.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm0plus.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl55xx_cm0plus.s
  group Application/User/CM0PLUS/Core
    ../CM0PLUS/Core/Src/: gpio.c ipcc.c ipcc_if.c main.c rtc.c stm32_lpm_if.c stm32wlxx_hal_msp.c stm32wlxx_it.c subghz.c sys_app.c timer_if.c
  group Application/User/CM0PLUS/MbMux
    ../CM0PLUS/MbMux/: features_info.c mbmux.c mbmuxif_radio.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c
  group Application/User/CM0PLUS/SubGHz_Phy/App
    ../CM0PLUS/SubGHz_Phy/App/: app_subghz_phy.c
  group Application/User/CM0PLUS/SubGHz_Phy/Target
    ../CM0PLUS/SubGHz_Phy/Target/: radio_board_if.c
  group Application/User/Common/System
    ../Common/System/: sys_debug.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c radio_fw.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
