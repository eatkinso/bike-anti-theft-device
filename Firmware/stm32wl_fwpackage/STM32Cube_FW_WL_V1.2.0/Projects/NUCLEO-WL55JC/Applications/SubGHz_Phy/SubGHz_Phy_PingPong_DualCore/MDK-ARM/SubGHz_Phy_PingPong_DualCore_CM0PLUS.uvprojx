# Keil uVision project SubGHz_Phy_PingPong_DualCore_CM0PLUS.uvprojx, settings and files
target SubGHz_Phy_PingPong_DualCore_CM0PLUS (6140000::V6.14::ARMCLANG)
  device: STM32WL55JCIx:CM0P STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20004000-0x20007FFF) IRAM2(0x2000C000-0x2000FFFF) IROM(0x8020000-0x803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+") TZ
  output: SubGHz_Phy_PingPong_DualCore_CM0PLUS +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM0PLUS,USE_HAL_DRIVER,STM32WL55xx
  c misc: -fshort-enums
  c include: ../CM0PLUS/Core/Inc;../CM0PLUS/SubGHz_Phy/App;../CM0PLUS/SubGHz_Phy/Target;../CM0PLUS/MbMux;../Common/Board;../Common/System;../Common/MbMux;../../../../../../Drivers/BSP/STM32WLxx_Nucleo;../../../../../../Utilities/trace/adv_trace;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x2000c000 size 0x4000
  scatter file: stm32wl55xx_flash_cm0plus.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm0plus.s
  group Application/User/Common/System
    ../Common/System/: sys_debug.c
  group Application/User/CM0PLUS/SubGHz_Phy/App
    ../CM0PLUS/SubGHz_Phy/App/: app_subghz_phy.c
  group Application/User/CM0PLUS/SubGHz_Phy/Target
    ../CM0PLUS/SubGHz_Phy/Target/: radio_board_if.c
  group Application/User/CM0PLUS/Core
    ../CM0PLUS/Core/Src/: main.c gpio.c ipcc.c rtc.c subghz.c ipcc_if.c stm32_lpm_if.c sys_app.c timer_if.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Application/User/CM0PLUS/MbMux
    ../CM0PLUS/MbMux/: features_info.c mbmux.c mbmuxif_radio.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_subghz.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio_driver.c radio_fw.c radio.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
