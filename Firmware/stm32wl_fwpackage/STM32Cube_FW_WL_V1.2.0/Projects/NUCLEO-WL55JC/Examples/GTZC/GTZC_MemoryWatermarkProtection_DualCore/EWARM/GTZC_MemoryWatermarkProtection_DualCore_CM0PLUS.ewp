# IAR project GTZC_MemoryWatermarkProtection_DualCore_CM0PLUS.ewp, settings and files
configuration GTZC_MemoryWatermarkProtection_DualCore_CM0PLUS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M0+ ST STM32WL55JC_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM0PLUS; STM32WL55xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../CM0PLUS/Inc; ../Common/System/; ../../../../../../Drivers/BSP/STM32WLxx_Nucleo; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GTZC_MemoryWatermarkProtection_DualCore_CM0PLUS.hex
  ILINK.IlinkOutputFile: GTZC_MemoryWatermarkProtection_DualCore_CM0PLUS.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm0plus.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl55xx_cm0plus.s
  group Application/User/CM0PLUS
    ../CM0PLUS/Src/: main.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_gtzc.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
