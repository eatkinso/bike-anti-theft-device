# Keil uVision project Sigfox_PushButton_DualCore_CM0PLUS.uvprojx, settings and files
target Sigfox_PushButton_DualCore_CM0PLUS (6140000::V6.14::ARMCLANG)
  device: STM32WL55JCIx:CM0P STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20004000-0x20007FFF) IRAM2(0x2000C000-0x2000FFFF) IROM(0x8020000-0x803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+") TZ
  output: Sigfox_PushButton_DualCore_CM0PLUS +hex
  AfterMake: fromelf #L --bincombined --output=$L../@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . #L @L.bin 1 1
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM0PLUS,KMS_ENABLED,USE_HAL_DRIVER,STM32WL55xx,DISABLE_IMAGE_STATE_HANDLING,CMSIS_NVIC_VIRTUAL
  c misc: -fshort-enums
  c include: ../CM0PLUS/Core/Inc;../CM0PLUS/KMS/App;../CM0PLUS/Sigfox/App;../CM0PLUS/Sigfox/Target;../CM0PLUS/MbMux;../Common/Board;../Common/System;../Common/MbMux;../../../../../../Utilities/trace/adv_trace;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/Third_Party/Sigfox/Crypto;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core;../../../../../../Middlewares/ST/STM32_Key_Management_Services/iKMS;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/Third_Party/mbed-crypto/include;../../../../../../Middlewares/Third_Party/mbed-crypto/include/mbedtls;../../../../../../Middlewares/Third_Party/mbed-crypto/include/psa;../../../../../../Middlewares/Third_Party/Sigfox/Monarch;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WLxx_Nucleo;../../Linker_Common/MDK-ARM;../../2_Images_SECoreBin/Inc;../../2_Images_SBSFU/Common;../../2_Images_SBSFU/CM0PLUS/SBSFU/App
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x2000c000 size 0x4000
  scatter file: stm32wl55xx_flash_cm0plus.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm0plus.s
    ./: svc_handler.s
  group Application/User/Common/System
    ../Common/System/: sys_debug.c
  group Application/User/CM0PLUS/Sigfox/App
    ../CM0PLUS/Sigfox/App/: app_sigfox.c ee.c sgfx_cstimer.c sgfx_eeprom_if.c
  group Application/User/CM0PLUS/Sigfox/Target
    ../CM0PLUS/Sigfox/Target/: sgfx_credentials.c mcu_api.c mn_api.c radio_board_if.c rf_api.c se_nvm.c
  group Application/User/CM0PLUS/KMS/App
    ../CM0PLUS/KMS/App/: app_kms.c
  group Application/User/CM0PLUS/Core
    ../CM0PLUS/Core/Src/: main.c gpio.c ipcc.c lptim.c rtc.c flash_if.c ipcc_if.c stm32_lpm_if.c sys_app.c timer_if.c mn_lptim_if.c subghz.c stm32wlxx_it.c stm32wlxx_hal_msp.c sys_privileged_services.c sys_privileged_wrap.c
  group Application/User/CM0PLUS/MbMux
    ../CM0PLUS/MbMux/: features_info.c sigfox_info.c mbmux.c mbmuxif_sigfox.c mbmuxif_radio.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c sigfox_mbwrapper.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_lptim.c stm32wlxx_hal_subghz.c stm32wlxx_hal_cryp.c stm32wlxx_hal_cryp_ex.c stm32wlxx_hal_gtzc.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/MDK-ARM/STM32WL55JC_Nucleo_CM0PLUS/Exe/: se_interface_appli.txt
  group Middlewares/Sigfox
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest/: SFX_ADDON_RFP_V0.8.0_SE_FDL_MON_ASYNC.a
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib/: SFX_LIB_V2.10.0_SE_FDL_MON.a
    ../../../../../../Middlewares/Third_Party/Sigfox/Crypto/: Sgfx-Cmac-V1.0.0-CM0-O3.a sigfox_aes.c sigfox_data.c
    ../../../../../../Middlewares/Third_Party/Sigfox/Monarch/: Sgfx-Monarch-V2.0.1-CM0-O3.a
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_fw.c radio_driver.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
software components: CMSIS:CORE 4.3.0
